# Keil uVision project RMc_adam_GeneralRobotSystemCode.uvprojx, settings and files
target RMc_adam_GeneralRobotSystemCode (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: RMc_adam_GeneralRobotSystemCode +hex
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;         ../Drivers/STM32F4xx_HAL_Driver/Inc;         ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;         ../Middlewares/Third_Party/FreeRTOS/Source/include;         ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;         ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;         ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;         ../Drivers/CMSIS/Include;         ..\Algorithm;         ..\Drivers\Chip;         ..\Task;         ..\Drivers\Encoder;         ..\Applications\Software;         ..\Applications\Hardware;         ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;         ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;         ..\Algorithm\madgwickAHRS;         ..\Algorithm\MahonyAHRS;         ..\Drivers\Chip\MPU6050;         ..\Drivers\Chip\MPU6050\eMPL;         ..\Drivers\TF-MINI_PLUS
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ../Src/: main.c gpio.c freertos.c can.c crc.c dma.c i2c.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ./: startup_stm32f407xx.s
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drives/Chip
    ../Drivers/Chip/: BMI088driver.c BMI088Middleware.c ist8310driver.c ist8310driver_middleware.c
    ../Drivers/Chip/MPU6050/: mpu6050.c mpuiic.c
    ../Drivers/Chip/MPU6050/eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
  group Algorithm
    ../Algorithm/: pid.c Kalman_Filter_c.c CRC8_CRC16.c fifo.c small_tools.c
    ../Algorithm/madgwickAHRS/: madgwick.c
    ../Algorithm/MahonyAHRS/: MahonyAHRS.c
  group Task
    ../Task/: Chassis_Task.c Arm_Task.c
  group Drives/Encoder
    ../Drivers/Encoder/: Encoder.c
  group Applicantions/Hardware
    ../Applications/Hardware/: UART_data_transmit.c GPIO_output.c IMU_updata.c CAN_receive&send.c DBUS_remote_control.c GPIO_input_EXTI.c LED_control.c PWM_control.c time.c USB_VirCom.c
  group Applications/Software
    ../Applications/Software/: IMU_calculate.c Stxxid-Data-Transmission.c guard_chassis.c gimbal.c shoot.c NUC_communication.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Driver/TF_MINI_PLUS
    ../Drivers/TF-MINI_PLUS/: TF_MINI_PLUS_LaserRanging.c
software components: CMSIS:CORE 4.3.0
